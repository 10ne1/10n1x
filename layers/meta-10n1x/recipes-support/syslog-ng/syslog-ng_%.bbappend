FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

RDEPENDS_${PN}_remove += "update-rc.d"
