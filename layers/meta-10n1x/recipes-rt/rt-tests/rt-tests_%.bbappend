FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-cyclictest-pi_tests-hack-sources-to-build-on-musl.patch"

