FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

EXTRA_OECONF_remove += "--disable-modern-top"
