PACKAGECONFIG = "flac wavpack lame mad ao alsa magic opus oggvorbis"

DEPENDS += "libtool"
