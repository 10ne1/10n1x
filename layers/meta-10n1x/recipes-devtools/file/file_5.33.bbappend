SRCREV = "315cef2f699da3c31a54bd3c6c6070680fbaf1f5"
SRC_URI_remove += "file://fix-bogus-magic.patch file://CVE-2018-10360.patch"